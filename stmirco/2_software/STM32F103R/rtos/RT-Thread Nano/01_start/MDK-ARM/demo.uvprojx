# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Device/ST/STM32F1xx/Include;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Include;../RT-Thread;C:/Users/Administrator/STM32Cube/Repository/Packs/RealThread/RT-Thread/3.1.5/include/;C:/Users/Administrator/STM32Cube/Repository/Packs/RealThread/RT-Thread/3.1.5/bsp/_template/cubemx_config;C:/Users/Administrator/STM32Cube/Repository/Packs/RealThread/RT-Thread/3.1.5/finsh/;C:/Users/Administrator/STM32Cube/Repository/Packs/RealThread/RT-Thread/3.1.5/components/finsh
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/RT-Thread/RTOS/kernel
    C:/Users/Administrator/STM32Cube/Repository//Packs/RealThread/RT-Thread/3.1.5/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
    C:/Users/Administrator/STM32Cube/Repository//Packs/RealThread/RT-Thread/3.1.5/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    C:/Users/Administrator/STM32Cube/Repository//Packs/RealThread/RT-Thread/3.1.5/bsp/_template/cubemx_config/: board.c
  group Middlewares/RT-Thread/RTOS/shell
    C:/Users/Administrator/STM32Cube/Repository//Packs/RealThread/RT-Thread/3.1.5/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group Middlewares/RT-Thread/RTOS/device
    C:/Users/Administrator/STM32Cube/Repository//Packs/RealThread/RT-Thread/3.1.5/components/device/: device.c
software components: CMSIS:CORE 5.5.0
