# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,BOARD_STM32F407VET6_XWS
  c misc: -Wno-shift-negative-value -Wno-shift-count-negative -Wno-int-to-void-pointer-cast -Wno-unused-value
  c include: ../Core/Inc;../../common/busif;../../common/busif/core;../../common/logger;../../common/typebasic;../../common/flexbtn;../../common/qrcode;C:/emkit/libc/stmicro/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Inc;C:/emkit/libc/stmicro/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;C:/emkit/libc/stmicro/STM32Cube_FW_F4_V1.28.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;C:/emkit/libc/stmicro/STM32Cube_FW_F4_V1.28.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group components/device
    ../../common/busif/: i2c_eeprom.c i2c_lcd1602.c i2c_mpu6050.c i2c_ssd1306.c i2c_as5600.c i2c_bh1750.c i2c_lm75.c i2c_tca9548a.c i2c_pca9685.c i2c_pcf8574.c i2c_si5351.c i2c_ina219.c i2c_ina3221.c i2c_apds9960.c spi_tm1638.c spi_ad9833.c spi_ds1302.c spi_st7735.c spi_ad770x.c spi_mt6701.c spi_mfrc522.c spi_mcp2515.c gpio_hcsr04.c onewire_dht11.c onewire_ds18b20.c spi_w25qxx.c spi_nrf24l01.c
  group components/busif/core
    ../../common/busif/core/: pinctrl.c spimst.c swi2cmst.c swspimst.c i2cmst.c delay.c
    ../../common/busif/lowlevel/stm32hal/: lowlevel.c
    ../../../busif/common/busif/lowlevel/stm32hal/: syscall.c
    ../../../busif/common/typebasic/: bittab.c
  group components/flexbtn
    ../../common/flexbtn/: flexbtn.c flexbtn_demo.c
  group components/logger
    ../../common/logger/: logger.c hexdump.c
  group middlewares/qrcode
    ../../common/qrcode/: qr_demo.c qr_encode.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/emkit/libc/stmicro/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 6.0.0
