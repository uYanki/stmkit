# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: demo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32G070xx
  c misc: -Wno-shift-negative-value -Wno-shift-count-negative -Wno-int-to-void-pointer-cast -Wno-unused-value
  c include: ../Core/Inc;../Libraries;../Database;../../../../../../include;../../../02_axis;../../../02_axis/motdrv;../../../02_axis/pathplan;../../../02_axis/application;../../../02_axis/logicctrl;../../../03_func;../../../03_func/scope;../../../03_func/delay;../../../03_func/system;../../../03_func/filter;../../../03_func/alarm;../../bsp;..\..\database;../../bsp/enc;F:/xServo/libcpu/STM32Cube_FW_G0_V1.6.0/Drivers/STM32G0xx_HAL_Driver/Inc;F:/xServo/libcpu/STM32Cube_FW_G0_V1.6.0/Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;F:/xServo/libcpu/STM32Cube_FW_G0_V1.6.0/Drivers/CMSIS/Device/ST/STM32G0xx/Include;F:/xServo/libcpu/STM32Cube_FW_G0_V1.6.0/Drivers/CMSIS/Include;..\..\..\..\core\func\paratbl;..\..\..\..\core\func\comm\modbus
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c dma.c i2c.c spi.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    F:/xServo/libcpu/STM32Cube_FW_G0_V1.6.0/Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group axis
    ../../../../core/axis/: axis.c
    ../../../../core/axis/pathplan/: pathplan.c
    ../../../../core/axis/motdrv/: cursamp.c encsamp.c mclib.c motdrv.c
    ../../../../core/axis/logicctrl/: logicctrl.c
    ../../../../core/axis/application/: appmgr.c looprsp.c motencident.c offmotident.c openloop.c
  group func
    ../../../../core/func/alarm/: alarm.c almtbl.c paratbl.c
    ../../../../core/func/analog/: analog.c pwrmgr.c thermistor.c
    ../../../../core/func/delay/: delay.c
    ../../../../core/func/filter/: lpf.c
    ../../../../core/func/pinctrl/: dido.c hw_version.c led.c touch_probe.c
    ../../../../core/func/panel/: oled.c
    ../../../../core/func/scope/: scope.c
    ./: system.c
    ../../../../core/func/comm/modbus/: modbus.c
    ../../../../core/func/: func.c
    ../../../../core/: scheduler.c
    ../../../../core/func/paratbl/: storage.c
  group bsp
    ../../bsp/adc/: bsp_adc.c
    ../../bsp/crc/: bsp_crc.c
    ../../bsp/enc/: abs_mt6701.c abs_mt6816.c abs_tformat.c
    ../../bsp/gpio/: bsp_gpio.c
    ../../bsp/i2c/: bsp_i2c.c
    ../../bsp/qei/: bsp_qei.c
    ../../bsp/spi/: bsp_spi.c
    ../../bsp/tim/: bsp_tim.c
    ../../bsp/uart/: bsp_uart.c
    ../../bsp/: bsp.c
  group database
    ../../database/: paraattr.c
software components: CMSIS:CORE 5.5.0
