# Keil uVision project demo.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c misc: --diag_suppress=513,174,177
  c include: ..\..\..\..\libcpu\AT32F403A_407_Firmware_Library_V2.1.9\libraries\drivers\inc;..\..\..\..\libcpu\AT32F403A_407_Firmware_Library_V2.1.9\libraries\cmsis\cm4\core_support;..\..\..\..\libcpu\AT32F403A_407_Firmware_Library_V2.1.9\libraries\cmsis\cm4\device_support;..\inc;..\..\bsp;..\..\bsp\enc;..\..\..\..\include;..\..\..\..\core;..\..\..\..\core\basic;..\..\..\..\core\basic\database\standard;..\..\..\..\core\basic\delay;..\..\..\..\core\basic\filter;..\..\..\..\core\basic\alarm;..\..\..\..\core\axis;..\..\..\..\core\axis\application;..\..\..\..\core\axis\logicctrl;..\..\..\..\core\axis\motdrv;..\..\..\..\core\axis\pathplan;..\..\..\..\core\func;..\..\..\..\core\func\scope;..\..\..\..\core\func\delay;;..\..\..\..\core\func\filter;..\..\..\..\core\func\alarm;..\..\..\..\core\func\paratbl;..\..\..\..\core\func\comm\modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: main.c at32f403a_407_clock.c at32f403a_407_int.c at32f403a_407_wk_config.c wk_system.c
  group cmsis
    ../../../../libcpu/AT32F403A_407_Firmware_Library_V2.1.9/libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../../../../libcpu/AT32F403A_407_Firmware_Library_V2.1.9/libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group fwlib
    ../../../../libcpu/AT32F403A_407_Firmware_Library_V2.1.9/libraries/drivers/src/: at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c at32f403a_407_acc.c at32f403a_407_adc.c
  group sched
    ../../../../core/: scheduler.c
  group axis/application
    ../../../../core/axis/application/: appmgr.c motencident.c looprsp.c offmotident.c openloop.c
  group axis
    ../../../../core/axis/: axis.c
    ../../../../core/axis/pathplan/: pathplan.c
    ../../../../core/axis/motdrv/: motdrv.c cursamp.c encsamp.c mclib.c
    ../../../../core/axis/logicctrl/: logicctrl.c
  group func
    ../../../../core/func/: func.c
    ../../../../core/func/scope/: scope.c
    ../../../../core/func/panel/: oled.c
    ../../../../core/func/pinctrl/: dido.c hw_version.c touch_probe.c
    ../../../../core/func/analog/: analog.c pwrmgr.c thermistor.c
    ../../../../core/func/comm/modbus/: modbus.c
    ../../../../core/func/paratbl/: storage.c
  group database
    ../../../../core/basic/alarm/: almtbl.c
    ../../../../core/basic/database/standard/: paraattr.c
  group bsp/enc
    ../../bsp/enc/: abs_mt6701.c abs_mt6816.c bsp_absenc.c abs_tformat.c
  group bsp
    ../../bsp/adc/: bsp_adc.c
    ../../bsp/can/: bsp_can.c
    ../../bsp/crc/: bsp_crc.c
    ../../bsp/gpio/: bsp_gpio.c
    ../../bsp/i2c/: bsp_i2c.c
    ../../bsp/qei/: bsp_qei.c
    ../../bsp/qeo/: bsp_qeo.c
    ../../bsp/spi/: bsp_spi.c
    ../../bsp/tim/: bsp_tim.c
    ../../bsp/uart/: bsp_uart.c dbguart.c
    ../../bsp/: bsp.c
  group basic
    ../../../../core/basic/alarm/: alarm.c
    ../../../../core/basic/delay/: delay.c
    ../../../../core/basic/filter/: fft.c lpf.c
