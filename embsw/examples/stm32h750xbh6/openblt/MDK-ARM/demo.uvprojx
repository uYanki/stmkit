# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx,USE_FULL_LL_DRIVER
  c include: ../USB_DEVICE/App;../USB_DEVICE/Target;../Core/Inc;F:/app_usb/embsw/platform/STM32Cube_FW_H7_V1.11.0/Drivers/STM32H7xx_HAL_Driver/Inc;F:/app_usb/embsw/platform/STM32Cube_FW_H7_V1.11.0/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;F:/app_usb/embsw/platform/STM32Cube_FW_H7_V1.11.0/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;F:/app_usb/embsw/platform/STM32Cube_FW_H7_V1.11.0/Drivers/CMSIS/Device/ST/STM32H7xx/Include;F:/app_usb/embsw/platform/STM32Cube_FW_H7_V1.11.0/Drivers/CMSIS/Include;F:/app_usb/embsw/platform/STM32Cube_FW_H7_V1.11.0/Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;../../../../../components;../../../../../include;../../../../middlewares/OpenBLT/source;../../../../middlewares/OpenBLT/ports/ARMCM7_STM32H7
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h7xx.sct
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: hooks.c led.c main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usbd_bulk.c usb_device.c usbd_desc.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/USB_Device_Library
    F:/app_usb/embsw/platform/STM32Cube_FW_H7_V1.11.0/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/OpenBLT/Core
    ../../../../middlewares/OpenBLT/source/: asserts.c backdoor.c boot.c com.c cop.c file.c net.c xcp.c
  group Middlewares/OpenBLT/Port
    ../../../../middlewares/OpenBLT/ports/ARMCM7_STM32H7/: can.c cpu.c flash.c nvm.c rs232.c timer.c usb.c
    ../../../../middlewares/OpenBLT/ports/ARMCM7_STM32H7/Keil/: cpu_comp.c
  group Drivers/STM32H7xx_HAL_Driver
    F:/app_usb/embsw/platform/STM32Cube_FW_H7_V1.11.0/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_exti.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_gpio.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_usart.c stm32h7xx_ll_dma.c
software components: CMSIS:CORE 5.5.0
