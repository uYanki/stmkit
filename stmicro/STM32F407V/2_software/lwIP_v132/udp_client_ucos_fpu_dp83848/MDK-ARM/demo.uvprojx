# Keil uVision project demo.uvprojx, settings and files
target STM32F407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pro +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,ARM_MATH_CM4,STM32F40_41xxx
  c include: ..\Core;..\..\common\lwip_v1.3.2\port\STM32F4x7\Standalone;..\..\common\lwip_v1.3.2\src\api;..\..\common\lwip_v1.3.2\src\core\ipv4;..\..\common\lwip_v1.3.2\src\include\ipv4\lwip;..\..\common\lwip_v1.3.2\src\include\lwip;..\..\common\lwip_v1.3.2\src\netif\ppp;..\..\common\lwip_v1.3.2\port\STM32F4x7\arch;..\..\common\lwip_v1.3.2\src\include\netif;..\..\common\lwip_v1.3.2\src\include;..\..\common\lwip_v1.3.2\src\include\lwip;..\..\common\lwip_v1.3.2\port\STM32F4x7;..\..\common\lwip_v1.3.2\src\include\ipv4;..\..\common\ucos2\Port;..\..\common\ucos2\Source;..\..\common\STM32F4x7_ETH_Driver\inc;C:\emkit\libc\stmicro\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;C:\emkit\libc\stmicro\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\CMSIS\Include;C:\emkit\libc\stmicro\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ../Core/: bsp.c main.c netconf.c stm32f4x7_eth_bsp.c system_stm32f4xx.c stm32f4xx_it.c udpclient.c
  group LWIP
    ../../common/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../common/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../common/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../common/lwip_v1.3.2/src/netif/: etharp.c loopif.c
    ../../common/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
  group ETH_Driver
    ../../common/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group StdPeriphLib
    C:/emkit/libc/stmicro/STM32F4xx_DSP_StdPeriph_Lib_V1.9.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ./: startup_stm32f40_41xxx_ucos.s
    C:/emkit/libc/stmicro/STM32F4xx_DSP_StdPeriph_Lib_V1.9.0/Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group UCOS2
    ../../common/ucos2/Port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
    ../../common/ucos2/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
software components: CMSIS:CORE 5.5.0
