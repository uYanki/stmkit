# Keil uVision project demo.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F415CBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F415CBT7,USE_STDPERIPH_DRIVER,BOARD_USER_DEFINED
  c misc: --diag_suppress=513,177
  c include: C:\emkit\libc\arterytek\AT32F415_Firmware_Library_V2.1.6\libraries\drivers\inc;C:\emkit\libc\arterytek\AT32F415_Firmware_Library_V2.1.6\libraries\cmsis\cm4\core_support;C:\emkit\libc\arterytek\AT32F415_Firmware_Library_V2.1.6\libraries\cmsis\cm4\device_support;C:\emkit\libc\arterytek\AT32F415_Firmware_Library_V2.1.6\middlewares\i2c_application_library;..\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c wk_system.c at32f415_int.c at32f415_wk_config.c dbguart.c
  group fwlib
    C:/emkit/libc/arterytek/AT32F415_Firmware_Library_V2.1.6/libraries/drivers/src/: at32f415_adc.c at32f415_can.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
  group cmsis
    C:/emkit/libc/arterytek/AT32F415_Firmware_Library_V2.1.6/libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f415.s
    C:/emkit/libc/arterytek/AT32F415_Firmware_Library_V2.1.6/libraries/cmsis/cm4/device_support/: system_at32f415.c
