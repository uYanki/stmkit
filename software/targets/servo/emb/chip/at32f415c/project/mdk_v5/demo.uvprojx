# Keil uVision project demo.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F415CBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F415CBT7,USE_STDPERIPH_DRIVER,BOARD_USER_DEFINED
  c misc: --diag_suppress=513,177
  c include: ..\..\..\..\..\..\..\platform\AT32F415_Firmware_Library_V2.1.6\libraries\drivers\inc;..\..\..\..\..\..\..\platform\AT32F415_Firmware_Library_V2.1.6\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\..\platform\AT32F415_Firmware_Library_V2.1.6\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\..\platform\AT32F415_Firmware_Library_V2.1.6\middlewares\i2c_application_library;..\inc;..\..\bsp;..\..\bsp\enc;..\..\..\..\..\..\..\components\typebasic;..\..\..\..\;..\..\..\..\basic;..\..\..\..\basic\alarm;..\..\..\..\basic\delay;..\..\..\..\basic\filter;..\..\..\..\axis\application;..\..\..\..\basic\database\standard;..\..\..\..\axis;..\..\..\..\axis\logicctrl;..\..\..\..\axis\motdrv;..\..\..\..\axis\pathplan;..\..\..\..\func;..\..\..\..\func\scope;..\..\..\..\func\delay;..\..\..\..\func\filter;..\..\..\..\func\alarm;..\..\..\..\func\paratbl;..\..\..\..\func\comm\modbus
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c wk_system.c at32f415_int.c at32f415_wk_config.c
  group fwlib
    ../../../../../../../platform/AT32F415_Firmware_Library_V2.1.6/libraries/drivers/src/: at32f415_adc.c at32f415_can.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
  group cmsis
    ../../../../../../../platform/AT32F415_Firmware_Library_V2.1.6/libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f415.s
    ../../../../../../../platform/AT32F415_Firmware_Library_V2.1.6/libraries/cmsis/cm4/device_support/: system_at32f415.c
  group sched
    ../../../../: scheduler.c
  group axis/application
    ../../../../axis/application/: appmgr.c motencident.c looprsp.c offmotident.c openloop.c
  group axis
    ../../../../axis/: axis.c
    ../../../../axis/pathplan/: pathplan.c
    ../../../../axis/motdrv/: motdrv.c cursamp.c encsamp.c mclib.c
    ../../../../axis/logicctrl/: logicctrl.c
  group func
    ../../../../func/: func.c
    ../../../../func/scope/: scope.c
    ../../../../func/panel/: oled.c
    ../../../../func/pinctrl/: dido.c hw_version.c touch_probe.c
    ../../../../func/analog/: analog.c pwrmgr.c thermistor.c
    ../../../../func/comm/modbus/: modbus.c
    ../../../../func/paratbl/: storage.c
  group bsp/enc
    ../../bsp/enc/: abs_mt6701.c bsp_absenc.c abs_tformat.c
  group bsp
    ../../bsp/adc/: bsp_adc.c
    ../../bsp/can/: bsp_can.c
    ../../bsp/crc/: bsp_crc.c
    ../../bsp/gpio/: bsp_gpio.c
    ../../bsp/i2c/: bsp_i2c.c
    ../../bsp/qei/: bsp_qei.c
    ../../bsp/tim/: bsp_tim.c
    ../../bsp/uart/: bsp_uart.c dbguart.c
    ../../bsp/: bsp.c
  group middleware/i2c_utils
    ../../../../../../../platform/AT32F415_Firmware_Library_V2.1.6/middlewares/i2c_application_library/: i2c_application.c
  group basic
    ../../../../basic/alarm/: alarm.c almtbl.c
    ../../../../basic/database/standard/: paraattr.c
    ../../../../basic/delay/: delay.c
    ../../../../basic/filter/: fft.c lpf.c
