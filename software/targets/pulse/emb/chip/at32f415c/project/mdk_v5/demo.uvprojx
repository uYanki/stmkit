# Keil uVision project demo.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F415CBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F415CBT7,USE_STDPERIPH_DRIVER,BOARD_USER_DEFINED
  c misc: --diag_suppress=513,177
  c include: ..\..\..\..\..\..\..\platform\AT32F415_Firmware_Library_V2.1.6\libraries\drivers\inc;..\..\..\..\..\..\..\platform\AT32F415_Firmware_Library_V2.1.6\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\..\platform\AT32F415_Firmware_Library_V2.1.6\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\..\platform\AT32F415_Firmware_Library_V2.1.6\middlewares\i2c_application_library;..\..\..\..\..\..\..\components\typebasic;..\inc;..\..\bsp;..\..\..\..\;..\..\..\..\basic;..\..\..\..\basic\alarm;..\..\..\..\basic\delay;..\..\..\..\basic\filter;..\..\..\..\basic\database\standard;..\..\..\..\func;..\..\..\..\func\paratbl;..\..\..\..\func\comm\modbus
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c wk_system.c at32f415_int.c at32f415_wk_config.c
  group fwlib
    ../../../../../../../platform/AT32F415_Firmware_Library_V2.1.6/libraries/drivers/src/: at32f415_adc.c at32f415_can.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
  group cmsis
    ../../../../../../../platform/AT32F415_Firmware_Library_V2.1.6/libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f415.s
    ../../../../../../../platform/AT32F415_Firmware_Library_V2.1.6/libraries/cmsis/cm4/device_support/: system_at32f415.c
  group sched
    ../../../../: scheduler.c
  group func
    ../../../../func/: func.c
    ../../../../func/pinctrl/: dido.c
    ../../../../func/analog/: analog.c
    ../../../../func/comm/modbus/: modbus.c
    ../../../../func/paratbl/: storage.c paratbl.c
    ../../../../func/pulse/: pulse.c
    ../../../../func/hrtim/: hrtim.c
  group bsp
    ../../bsp/adc/: bsp_adc.c
    ../../bsp/can/: bsp_can.c
    ../../bsp/crc/: bsp_crc.c
    ../../bsp/gpio/: bsp_gpio.c
    ../../bsp/i2c/: bsp_i2c.c
    ../../bsp/tim/: bsp_tim.c
    ../../bsp/uart/: bsp_uart.c dbguart.c
    ../../bsp/: bsp.c
  group middleware/i2c_utils
    ../../../../../../../platform/AT32F415_Firmware_Library_V2.1.6/middlewares/i2c_application_library/: i2c_application.c
  group basic
    ../../../../basic/alarm/: alarm.c almtbl.c
    ../../../../basic/database/standard/: paraattr.c
    ../../../../basic/delay/: delay.c
    ../../../../basic/filter/: lpf.c
