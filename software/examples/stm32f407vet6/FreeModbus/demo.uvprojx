# Keil uVision project demo.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=25000000
  c include: ..\..\fwlib\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\fwlib\Libraries\CMSIS\Include;..\..\board;.\Core\inc;..\..\3rdparty\freemodbus\modbus\include;.\Core\src\mbslave;..\..\3rdparty\freemodbus\modbus\rtu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./Core/src/: startup_stm32f40_41xxx.s
  group cmsis
    ./Core/src/: system_stm32f4xx.c
  group user
    ./Core/inc/: board_conf.h
    ../../board/: pinmap.h
    ./Core/src/: main.c stm32f4xx_it.c
  group bsp
    ../../board/bsp/: key.c led.c uart.c adc.c
  group sensor/ds18b20
    ../../board/sensor/ds18b20/: ds18b20.c
  group system
    ../../board/system/: sleep.c autoinit.c
  group paratbl
    ./Core/inc/paratbl/: attr.h tbl.h
    ./Core/src/: paratbl.c
  group pulse
    ../../board/pulse/: wave.c calc.c
  group fwlib
    ../../fwlib/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group 3rdparty/modbus/core
    ../../3rdparty/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../3rdparty/freemodbus/modbus/: mb.c
  group 3rdparty/modbus/rtu
    ../../3rdparty/freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
  group 3rdparty/modbus/port
    ./Core/src/mbslave/: mbslave.c portevent.c portserial.c porttimer.c
  group encoder
    ../../board/enc/: absEnc.c incEnc.c pulse.c hallEnc.c rotEnc.c
