# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;F:/embkit/software/platform/STM32Cube_FW_H7_V1.11.0/Drivers/STM32H7xx_HAL_Driver/Inc;F:/embkit/software/platform/STM32Cube_FW_H7_V1.11.0/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;F:/embkit/software/platform/STM32Cube_FW_H7_V1.11.0/Drivers/CMSIS/Device/ST/STM32H7xx/Include;F:/embkit/software/platform/STM32Cube_FW_H7_V1.11.0/Drivers/CMSIS/Include;..\..\..\..\..\middlewares\cherryusb\class\wireless;..\..\..\..\..\middlewares\cherryusb\class\cdc;../../../../../middlewares/cherryusb/core;../../../../../middlewares/cherryusb/common;..\..\..\..\..\middlewares\cherryusb\third_party\lwip-2.1.2\src\include;..\..\..\..\..\middlewares\cherryusb\third_party\dhcp-server;..\..\..\..\..\middlewares\cherryusb\third_party\dns-server;..\..\..\..\..\middlewares\CherryUSB\third_party\lwip-2.1.2\src\apps\http
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c cdc_rndis.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    F:/embkit/software/platform/STM32Cube_FW_H7_V1.11.0/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middleware/CherryUSB
    ../../../../../middlewares/cherryusb/core/: usbd_core.c
    ../../../../../middlewares/cherryusb/port/dwc2/: usb_dc_dwc2.c usb_glue_st.c
    ../../../../../middlewares/cherryusb/class/wireless/: usbd_rndis.c
  group Middleware/lwIP/API
    ../../../../../middlewares/cherryusb/third_party/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middleware/lwIP/Netif
    ../../../../../middlewares/cherryusb/third_party/lwip-2.1.2/src/netif/: ethernet.c
  group Middleware/lwIP/Core
    ../../../../../middlewares/cherryusb/third_party/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middleware/lwIP/Core/IPv6
    ../../../../../middlewares/cherryusb/third_party/lwip-2.1.2/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group Middleware/lwIP/Core/IPv4
    ../../../../../middlewares/cherryusb/third_party/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middleware/dnserver
    ../../../../../middlewares/cherryusb/third_party/dns-server/: dnserver.c
  group Middleware/dhserver
    ../../../../../middlewares/cherryusb/third_party/dhcp-server/: dhserver.c
  group Middleware/lwIP/App/httpd
    ../../../../../middlewares/CherryUSB/third_party/lwip-2.1.2/src/apps/http/: altcp_proxyconnect.c http_client.c httpd.c fs.c
software components: CMSIS:CORE 5.5.0
