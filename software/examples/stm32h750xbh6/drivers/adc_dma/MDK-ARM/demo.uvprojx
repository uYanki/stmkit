# Keil uVision project demo.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: demo +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,ARM_MATH_CM7
  c include: ../Core/Inc;../../../Board;C:/Users/Administrator/AppData/Local/Arm/Packs/ARM/CMSIS/5.8.0/CMSIS/DSP/Include;F:/gsdk/platform/stm32h7_hal/fwlib/STM32Cube_FW_H7_V1.11.0/Drivers/STM32H7xx_HAL_Driver/Inc;F:/gsdk/platform/stm32h7_hal/fwlib/STM32Cube_FW_H7_V1.11.0/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;F:/gsdk/platform/stm32h7_hal/fwlib/STM32Cube_FW_H7_V1.11.0/Drivers/CMSIS/Device/ST/STM32H7xx/Include;F:/gsdk/platform/stm32h7_hal/fwlib/STM32Cube_FW_H7_V1.11.0/Drivers/CMSIS/Include;..\Bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Inc/: gconf.h
    ../Core/Src/: main.c gpio.c adc.c bdma.c dma.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/User/Bsp
    ../Bsp/: adc_ts.c arm_atan2_f32.c bsp_uart.c dsp_fft.c sleep.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
software components: CMSIS:CORE 6.0.0, CMSIS:DSP 1.15.0
